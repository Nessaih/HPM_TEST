# IAR project APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AC78428xILA AutoChips AC78428xILA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AC7842X
  ICCARM.CCIncludePath2: ..\..\rtos\config; ..\..\rtos\source\cli; ..\..\rtos\source\include; ..\..\rtos\source\portable\IAR\ARM_CM4F; ..\..\sdk\base\include; ..\..\sdk\device\config; ..\..\sdk\device\include; ..\..\sdk\hal\include; ..\..\sdk\hal\src\hsm\hsmpackage\include; ..\..\sdk\hal\src\hsm\hsmpackage\include\common; ..\..\sdk\hal\src\hsm\hsmpackage\include\config; ..\..\src; ..\..\src\driver; ..\..\src\driver\adc; ..\..\src\driver\can; ..\..\src\driver\clock; ..\..\src\driver\dma; ..\..\src\driver\flash; ..\..\src\driver\i2c; ..\..\src\driver\nvic; ..\..\src\driver\pin; ..\..\src\driver\rtc; ..\..\src\driver\spi; ..\..\src\driver\spm; ..\..\src\driver\timer; ..\..\src\driver\uart; ..\..\src\driver\eio; ..\..\src\driver\wdg; ..\..\src\include; ..\..\src\include\app; ..\..\src\include\service; ..\..\src\include\common; ..\..\src\include\core; ..\..\src\service\fal; ..\..\src\service\fdb; ..\..\src\service\se\inc; ..\..\src\service\program; ..\..\src\service\j1939; ..\..\src\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\rtos\config
  OBJCOPY.OOCOutputFile: APP.srec
  prebuild: ..\..\script\PreBuild.bat
  postbuild: ..\..\script\PostBuild.bat  $TARGET_BPATH$
  ILINK.IlinkOutputFile: TZS100_VPU.out
  ILINK.IlinkIcfFile: ..\..\cmsis\iar\app_ac7842x.icf
  ILINK.IlinkAdditionalLibs: ..\..\src\lib\vse_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis
    ../../cmsis/iar/: startup_ac7842x.s
  group rtos/config
    ../../rtos/config/: FreeRTOSConfig.h
  group rtos/source
    ../../rtos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group rtos/source/cli
    ../../rtos/source/cli/: FreeRTOS_CLI.c
  group rtos/source/include
    ../../rtos/source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group rtos/source/portable/heap
    ../../rtos/source/portable/MemMang/: heap_4.c
  group rtos/source/portable/mpu
    ../../rtos/source/portable/Common/: mpu_wrappers_v2.c
  group rtos/source/portable/port
    ../../rtos/source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group sdk/base/src
    ../../sdk/base/src/: OsIf.c OsIf_Critical.c
  group sdk/device/src
    ../../sdk/device/src/: Debugout_AC784xx.c Exception_BackTrace.c Exception_Fault.s System_AC784xx.c
  group sdk/hal/src/acmp
    ../../sdk/hal/src/acmp/: Acmp_Hal.c
  group sdk/hal/src/adc
    ../../sdk/hal/src/adc/: Adc_Hal.c
  group sdk/hal/src/can
    ../../sdk/hal/src/can/: Can_Hal.c
  group sdk/hal/src/crc
    ../../sdk/hal/src/crc/: Crc_Hal.c
  group sdk/hal/src/cse
    ../../sdk/hal/src/cse/: AC784xx_Cse_Reg.c Cse_Hal.c
  group sdk/hal/src/eep
    ../../sdk/hal/src/eep/: eep_drv.c Eep_Hal.c
  group sdk/hal/src/eio
    ../../sdk/hal/src/eio/: Eio_Common_Hal.c Eio_I2c_Hal.c Eio_Uart_Hal.c
  group sdk/hal/src/flash
    ../../sdk/hal/src/flash/: Fls_Hal.c
  group sdk/hal/src/gpio
    ../../sdk/hal/src/gpio/: Gpio_Hal.c
  group sdk/hal/src/gpt
    ../../sdk/hal/src/gpt/: Rtc_Hal.c Timer_Hal.c
  group sdk/hal/src/hsm
    ../../sdk/hal/src/hsm/: Hsm_Hal.c Otp_Hal.c
  group sdk/hal/src/hsm/hsmpackage/src
    ../../sdk/hal/src/hsm/hsmpackage/src/: eHSM_Compt_Bitmap.c eHSM_Dspt_CryObj_Ip.c eHSM_Dspt_lp.c eHSM_If_Evita_AsymCper_Ip.c eHSM_If_Evita_Counter_Ip.c eHSM_If_Evita_ErrCode_Ip.c eHSM_If_Evita_Hash_Ip.c eHSM_If_Evita_Key_Ip.c eHSM_If_Evita_Rng_Ip.c eHSM_If_Evita_SymCper_Ip.c eHSM_If_Evita_Timer_Ip.c eHSM_If_Ext_Sm9_Ip.c eHSM_If_Ext_SysMgr_Ip.c eHSM_If_She_ErrCode_Ip.c eHSM_If_She_Ip.c eHSM_Mailbox_Ip.c eHSM_Mgr_Ctx_Ip.c eHSM_Srv_AsymCper_Ip.c eHSM_Srv_Ciper_Ip.c eHSM_Srv_Counter_Ip.c eHSM_Srv_Ext_Ip.c eHSM_Srv_Hash_Ip.c eHSM_Srv_Key_Ip.c eHSM_Srv_Mgr_Ip.c eHSM_Srv_Rng_Ip.c eHSM_Srv_Timer_Ip.c
  group sdk/hal/src/i2c
    ../../sdk/hal/src/i2c/: I2c_Hal.c
  group sdk/hal/src/lin
    ../../sdk/hal/src/lin/: Lin_Hal.c
  group sdk/hal/src/mcl
    ../../sdk/hal/src/mcl/: Ctu_Hal.c Dma_Hal.c Mpu_Hal.c Pbr_Hal.c
  group sdk/hal/src/mcu
    ../../sdk/hal/src/mcu/: AC784xx_Ckgen_Reg.c Ckgen_Hal.c Cmu_Hal.c Core_Hal.c Rcm_Hal.c Spm_Hal.c
  group sdk/hal/src/pwm
    ../../sdk/hal/src/pwm/: Pwm_Hal.c
  group sdk/hal/src/safety
    ../../sdk/hal/src/safety/: Eim_Hal.c Esm_Hal.c Smu_Hal.c
  group sdk/hal/src/sent
    ../../sdk/hal/src/sent/: Sent_Hal.c
  group sdk/hal/src/spi
    ../../sdk/hal/src/spi/: Spi_Hal.c
  group sdk/hal/src/uart
    ../../sdk/hal/src/uart/: Uart_Hal.c
  group sdk/hal/src/wdg
    ../../sdk/hal/src/wdg/: Wdg_Hal.c
  group src
    ../../src/: main.c
  group src/app/fct
    ../../src/app/fct/: fct.c fct.h fct_cmd.c fct_cmd.h fct_shell.c fct_shell.h
  group src/app/hpm
    ../../src/app/hpm/: hpm.c hpm.h hpm_can.c hpm_can.h hpm_cfg.c hpm_cfg.h hpm_content.h hpm_control.c hpm_control.h hpm_data.c hpm_data.h hpm_data_recv.c hpm_data_recv.h hpm_dev.c hpm_dev.h hpm_flash.c hpm_flash.h hpm_mgr.c hpm_mgr.h hpm_net.c hpm_net.h hpm_ota_ecu.c hpm_ota_ecu.h hpm_ota_tbox.c hpm_ota_tbox.h hpm_pack.c hpm_pack.h hpm_param_fetch.c hpm_param_fetch.h hpm_param_parse.c hpm_param_parse.h hpm_session.c hpm_session.h hpm_shell.c hpm_shell.h hpm_socket.c hpm_socket.h
  group src/common
    ../../src/common/: checksum.c cobs.c cqueue.c data_queue.c delay.c md5.c stateMachine.c tbox_dlist.c tbox_dlist.h tbox_hashmap.c tbox_mp.c tbox_mp.h
  group src/core
    ../../src/core/: tbox_core.c tbox_log.c tbox_log_inner.h tbox_memory.c tbox_memory_inner.h tbox_message.c tbox_message_inner.h tbox_module.c tbox_module_inner.h tbox_supervise.c tbox_supervish_inner.h tbox_task.c tbox_task.h
  group src/driver
    ../../src/driver/: driver.c drv_log.c drv_log.h
  group src/driver/adc
    ../../src/driver/adc/: drv_adc.c
  group src/driver/can
    ../../src/driver/can/: can_config.c drv_can.c
  group src/driver/clock
    ../../src/driver/clock/: drv_clock.c
  group src/driver/dma
    ../../src/driver/dma/: drv_dma.c
  group src/driver/eio
    ../../src/driver/eio/: drv_eio.c
  group src/driver/flash
    ../../src/driver/flash/: drv_flash_mcu.c drv_flash_nand.c drv_flash_nor.c drv_flash_sd.c spi_sdcard.c
  group src/driver/iic
    ../../src/driver/i2c/: drv_i2c.c
  group src/driver/nvic
    ../../src/driver/nvic/: drv_nivc.c
  group src/driver/pin
    ../../src/driver/pin/: drv_pin.c
  group src/driver/rtc
    ../../src/driver/rtc/: drv_rtc.c
  group src/driver/spi
    ../../src/driver/spi/: drv_spi_nor_flash.c drv_spi_sd_flash.c drv_spi_vse.c
  group src/driver/spm
    ../../src/driver/spm/: drv_spm.c
  group src/driver/timer
    ../../src/driver/timer/: drv_timer.c
  group src/driver/uart
    ../../src/driver/uart/: drv_uart.c drv_uart_485.c drv_uart_bt.c
  group src/driver/wdg
    ../../src/driver/wdg/: drv_wdg.c
  group src/include
    ../../src/include/: api_drv.h api_rtos.h tbox_config.h
  group src/include/app
    ../../src/include/app/: fct_if.h
  group src/include/common
    ../../src/include/common/: checksum.h cobs.h cqueue.h data_queue.h delay.h dlist.h md5.h stateMachine.h tbox_bits.h tbox_common.h tbox_dlist.h tbox_hashmap.h tbox_mp.h tbox_string.h
  group src/include/core
    ../../src/include/core/: tbox_core.h tbox_log.h tbox_memory.h tbox_message.h tbox_module.h tbox_supervise.h
  group src/include/service
    ../../src/include/service/: gnss_if.h uds_if.h
  group src/service
    ../../src/service/: service.c
  group src/service/4g
    ../../src/service/4g/: 4g.c 4g_at.c 4g_at_startup.c 4g_at_transmit.c 4g_data.c 4g_dev.c 4g_dial.c 4g_ftp.c 4g_if.c 4g_info.c 4g_mgr.c 4g_modem.c 4g_network.c 4g_power.c 4g_sequence_mgr.c 4g_sharememery.c 4g_shell.c 4g_sim.c 4g_sms.c 4g_socket.c 4g_time.c
  group src/service/adsp
    ../../src/service/adsp/: tbox_adsp.c
  group src/service/analog
    ../../src/service/analog/: analog.c analog.h
  group src/service/battery
    ../../src/service/battery/: battery.c
  group src/service/can
    ../../src/service/can/: can.c can_buserr.c can_busoff.c can_list.c can_mgr.c can_shell.c
  group src/service/cfg
    ../../src/service/cfg/: tbox_cfg.c
  group src/service/fal
    ../../src/service/fal/: fal.c fal_flash.c fal_onchip.c fal_partition.c
  group src/service/fdb
    ../../src/service/fdb/: fdb.c fdb_kvdb.c fdb_utils.c
  group src/service/fota
    ../../src/service/fota/: fota.c fota.h fota_com.c fota_com.h fota_content.h fota_shell.c fota_shell.h
  group src/service/gnss
    ../../src/service/gnss/: gnss.c gnss.h gnss_com.c gnss_com.h gnss_control.c gnss_control.h gnss_nmeap.c gnss_nmeap.h gnss_nmeap_def.h gnss_parse.c gnss_parse.h gnss_shell.c gnss_shell.h
  group src/service/j1939
    ../../src/service/j1939/: j1939.c j1939_al.c j1939_dl.c j1939_hal.c j1939_if.c j1939_nml.c j1939_pgn.c j1939_service.c j1939_tl.c
  group src/service/led
    ../../src/service/led/: led.c led.h led_key.c led_key.h led_shell.c led_shell.h led_tbox.c led_tbox.h
  group src/service/mode
    ../../src/service/mode/: tbox_check_power.c tbox_check_power.h tbox_mode.c
  group src/service/phm
    ../../src/service/phm/: tbox_phm.c tbox_phm_4g.c tbox_phm_4g.h tbox_phm_module.c tbox_phm_module.h
  group src/service/pm
    ../../src/service/pm/: tbox_pm.c tbox_pm_4g_mgr.c tbox_pm_4g_mgr.h tbox_pm_action.c tbox_pm_action.h tbox_pm_inner.h tbox_pm_io.c tbox_pm_state.c tbox_pm_state.h tbox_pm_time_reboot.c tbox_pm_time_reboot.h
  group src/service/program
    ../../src/service/program/: program.c
  group src/service/se
    ../../src/service/se/: se.c se.h se_mgr.c se_mgr.h se_shell.c se_shell.h
  group src/service/se/cfg
    ../../src/service/se/cfg/: vse_cfg.c
  group src/service/se/inc
    ../../src/service/se/inc/: des.h vse.h vse_algo.h vse_asym.h vse_block.h vse_cfg.h vse_file.h vse_query.h vse_random.h vse_scp.h vse_security.h vse_sm2za.h vse_type.h
  group src/service/shell
    ../../src/service/shell/: tbox_default_shell.c tbox_default_shell.h tbox_shell.c
  group src/service/time
    ../../src/service/time/: time.c time_backup.c time_backup.h time_shell.c time_shell.h time_sync.c time_sync.h
  group src/service/timer
    ../../src/service/timer/: stimer.c
  group src/service/version
    ../../src/service/version/: version.c
  group src/test
    ../../src/test/: test.c test_adc.c test_can.c test_dv.c test_flash.c test_j1939.c test_led.c test_log.c test_rtc.c test_timer.c
